# Copyright (c) 2019 LG Electronics, Inc.

require python3-lark-parser.inc

inherit setuptools3

BBCLASSEXTEND = "native nativesdk"
